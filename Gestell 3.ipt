# Autodesk Inventor part: Gestell 3
## iProperties
Created: 2010-08
Part Number: Gestell 3
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Author: Administrator
